# IAR project peripheral_ibeacon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; BLE50_ENABLED=1
  ICCARM.CCIncludePath2: $ING_SDK_ROOT$/bundles/typical/inc; $ING_SDK_ROOT$/bundles/typical/inc/os; $ING_SDK_ROOT$/src/BSP; $ING_SDK_ROOT$/src/FWlib; $ING_SDK_ROOT$/src/StartUP/ing918; $ING_SDK_ROOT$/src/Tools; $ING_SDK_ROOT$/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: peripheral_ibeacon.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkExtraOptions: -f $ING_SDK_ROOT$/bundles/typical/ING9187xx/symdefs.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group App
    src/: main.c
    ../../examples/peripheral_ibeacon/src/: profile.c
  group FWlib
    ../../src/FWlib/: peripheral_sysctrl.c peripheral_uart.c
  group StartUp
    src/: cstartup_ing91800.s
