# Keil uVision project coremark.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: coremark +hex
  AfterMake: fromelf.exe --bin -o coremark.bin ./output/coremark.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ITERATIONS=1000,FLAGS_STR=\"TODO\"
  c misc: --gnu
  c include: ./coremark;./src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900888 size 35560
  group APP
    ./src/: main.c core_portme.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Coremark
    ./coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
