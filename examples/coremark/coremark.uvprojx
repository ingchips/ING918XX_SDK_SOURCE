# Keil uVision project coremark.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: coremark +hex
  AfterMake: fromelf.exe --bin -o coremark.bin ./output/coremark.axf
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,ITERATIONS=3000,FLAGS_STR=\"TODO\"
  c include: ./coremark;./src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 172032 size 368640
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c core_portme.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Coremark
    ./coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
software components: CMSIS:CORE 5.5.0
