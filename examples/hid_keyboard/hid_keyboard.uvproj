# Keil uVision project hid_keyboard.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: hid_keyboard +hex
  AfterMake: fromelf.exe --bin -o hid_keyboard.bin ./output/hid_keyboard.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_KEYS
  c misc: --gnu
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 196608 size 344064
  memory RVCT9: RAM 536901208 size 35240
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/exp/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: att_db_util.c trace.c btstack_sync.c gatt_client_util.c malloc_override.c ecc_driver.c ing918_uecc.lib
