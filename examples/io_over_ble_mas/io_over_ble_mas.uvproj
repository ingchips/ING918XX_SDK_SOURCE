# Keil uVision project io_over_ble_mas.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: io_over_ble_mas +hex
  AfterMake: fromelf.exe --bin -o io_over_ble_mas.bin ./output/io_over_ble_mas.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,IS_MASTER,IO_TYPE=IO_TYPE_UART_BIN
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c profile.c io_interf.c uart_driver.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c peripheral_pwm.c peripheral_gpio.c peripheral_ssp.c
  group Tools
    ../../src/Tools/: ad_parser.c blink.c rf_util.c ring_buf.c
