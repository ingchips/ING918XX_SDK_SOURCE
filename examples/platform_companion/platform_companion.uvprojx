# Keil uVision project platform_companion.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x2000000,0x00200000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: platform_companion +hex
  AfterMake: fromelf.exe --bin -o platform_companion.bin ./output/platform_companion.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../../bundles/rom/inc;../../bundles/rom/inc/os;../../src/BSP;../../src/FWlib;..\..\src\StartUP\ing20;../../src/Tools;../../src
  asm define: EFLASH_SEC_SIZE=4096
  library: MicroLIB
  memory RVCT4: ROM 0x2002000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x200
  memory RVCT10: RAM 0x200055c8 size 0x150
  link misc: --keep=main.o(*) --keep=*.*(i.platform_*) --keep=*.*(i.hci*) --keep=*.*(i.gap_*)
--keep=*.*(i.ll_*)
  group APP
    ./src/: main.c ing920_platform_lib.o
  group StartUP
    ./src/: startup_ing92000.s
  group FWlib
    ../../src/FWlib/: peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
