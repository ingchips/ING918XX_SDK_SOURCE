# Keil uVision project platform_companion.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING92000 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: platform_companion +hex
  AfterMake: fromelf.exe --bin -o platform_companion.bin ./output/platform_companion.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --gnu
  c include: ../../bundles/rom/inc;../../bundles/rom/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing920;../../src/Tools;../../src
  asm define: EFLASH_SEC_SIZE=4096
  library: MicroLIB
  memory RVCT4: ROM 0x2002000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=main.o(*)
  group APP
    ./src/: main.c ing920_platform_lib.lib
    ./scripts/: symdefs.m
  group StartUP
    ./src/: startup_ing92000.s
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
