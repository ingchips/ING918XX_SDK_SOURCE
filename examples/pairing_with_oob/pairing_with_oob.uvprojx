# Keil uVision project pairing_with_oob.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: pairing_with_oob +hex
  AfterMake: fromelf.exe --bin -o pairing_with_oob.bin ./output/pairing_with_oob.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, ROLE=1
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 196608 size 344064
  memory RVCT9: RAM 536901208 size 35240
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/exp/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../src/Tools/: trace.c ecc_driver.c ing918_uecc.lib ad_parser.c
software components: CMSIS:CORE 4.3.0
