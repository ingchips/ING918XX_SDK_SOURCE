# Keil uVision project peripheral_band.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_band +hex
  AfterMake: fromelf.exe --bin -o peripheral_band.bin ./output/peripheral_band.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,SIMULATION
  c misc: --gnu
  c include: ../peripheral_pedometer/src;../peripheral_pedometer/src/bh1790;../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 147456 size 131072
  memory RVCT9: RAM 536893744 size 9936
  group APP
    ./src/: main.c profile.c sig_services.c spi.c Display_LCD.c disp_task.c
    ../peripheral_pedometer/src/: bma2x2_support.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9185xx/: symdefs.m
  group BSP
    ../../src/BSP/: bma2x2.c iic.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_i2c.c peripheral_timer.c peripheral_ssp.c peripheral_pinctrl.c peripheral_rtc.c peripheral_gpio.c
  group bh1790
    ./src/bh1790/: bh1790.c heartRate.c hr_bh1790.c iirFilter.c lxCtrl.c movingAverage.c pw_bh1790.c pwCalc.c touchDet.c
software components: CMSIS:CORE 4.3.0
