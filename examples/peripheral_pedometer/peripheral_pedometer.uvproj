# Keil uVision project peripheral_pedometer.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_pedometer +hex
  AfterMake: fromelf.exe --bin -o peripheral_pedometer.bin ./output/peripheral_pedometer.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536910768 size 25680
  group APP
    ./src/: main.c profile.c step_calc.c bma2x2_support.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/: symdefs.m
  group BSP
    ../../src/BSP/: bma2x2.c iic.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_i2c.c peripheral_timer.c
