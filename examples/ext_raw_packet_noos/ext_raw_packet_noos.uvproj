# Keil uVision project ext_raw_packet_noos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: ext_raw_packet_noos +hex
  AfterMake: fromelf.exe --bin -o ext_raw_packet_noos.bin ./output/ext_raw_packet_noos.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,FOR_TX=1
  c misc: --gnu
  c include: ../../bundles/noos_extension/inc;../../bundles/noos_extension/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536874280 size 62168
  group APP
    ./src/: main.c profile.c noos_impl.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/noos_extension/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c
