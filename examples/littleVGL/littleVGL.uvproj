# Keil uVision project littleVGL.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: littleVGL +hex
  AfterMake: fromelf.exe --bin -o littleVGL.bin ./output/littleVGL.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER LCDMODULE_LCD128160
  c misc: --gnu
  c include: ../src;../../littleVGL/gui/src/core;../../littleVGL/gui/src/draw;../../littleVGL/gui/src/draw/sw;../../littleVGL/gui/src/draw/sdl;../../littleVGL/gui/src/extra;../../littleVGL/gui/src/extra/layouts;../../littleVGL/gui/src/extra/layouts/flex;../../littleVGL/gui/src/extra/layouts/grid;../../littleVGL/gui/src/extra/libs/bmp;../../littleVGL/gui/src/extra/libs/ffmpeg;../../littleVGL/gui/src/extra/libs/freetype;../../littleVGL/gui/src/extra/libs/fsdrv;../../littleVGL/gui/src/extra/libs/gif;../../littleVGL/gui/src/extra/libs/png;../../littleVGL/gui/src/extra/libs/qrcode;../../littleVGL/gui/src/extra/libs/sjpg;../../littleVGL/gui/src/extra/libs/;../../littleVGL/gui/src/extra/libs/rlottie;../../littleVGL/gui/src/extra/libs/others;../../littleVGL/gui/src/extra/libs/others/gridnav;../../littleVGL/gui/src/extra/libs/others/monkey;../../littleVGL/gui/src/extra/libs/others/snapshot;../../littleVGL/gui/src/extra/themes;../../littleVGL/gui/src/extra/themes/basic;../../littleVGL/gui/src/extra/themes/default;../../littleVGL/gui/src/extra/themes/mono;../../littleVGL/gui/src/extra/widgets;../../littleVGL/gui/src/extra/widgets/animimg;../../littleVGL/gui/src/extra/widgets/calendar;../../littleVGL/gui/src/extra/widgets/chart;../../littleVGL/gui/src/extra/widgets/colorwheel;../../littleVGL/gui/src/extra/widgets/imgbtn;../../littleVGL/gui/src/extra/widgets/keyboard;../../littleVGL/gui/src/extra/widgets/led;../../littleVGL/gui/src/extra/widgets/list;../../littleVGL/gui/src/extra/widgets/menu;../../littleVGL/gui/src/extra/widgets/meter;../../littleVGL/gui/src/extra/widgets/msgbox;../../littleVGL/gui/src/extra/widgets/span;../../littleVGL/gui/src/extra/widgets/spinbox;../../littleVGL/gui/src/extra/widgets/spinner;../../littleVGL/gui/src/extra/widgets/tabview;../../littleVGL/gui/src/extra/widgets/tileview;../../littleVGL/gui/src/extra/widgets/win;../../littleVGL/gui/src/font;../../littleVGL/gui/src/hal;../../littleVGL/gui/src/misc;../../littleVGL/gui;../../littleVGL;.\src;.\littleVGL\gui;.\littleVGL\gui\src;.\littleVGL\gui\examples\porting;.\src\lcd;.\src\spi;.\littleVGL\gui\examples\widgets;.\littleVGL\gui\src\misc;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x2a000 size 0x5a000
  memory RVCT9: RAM 0x20007520 size 0x8ae0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c peripheral_pwm.c peripheral_ssp.c peripheral_dma.c
  group Tools
    ../../src/Tools/: trace.c
  group gui_src
    ./littleVGL/gui/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./littleVGL/gui/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./littleVGL/gui/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./littleVGL/gui/src/extra/layouts/flex/: lv_flex.c
    ./littleVGL/gui/src/extra/layouts/grid/: lv_grid.c
    ./littleVGL/gui/src/extra/libs/bmp/: lv_bmp.c
    ./littleVGL/gui/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./littleVGL/gui/src/extra/libs/freetype/: lv_freetype.c
    ./littleVGL/gui/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./littleVGL/gui/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./littleVGL/gui/src/extra/libs/png/: lodepng.c lv_png.c
    ./littleVGL/gui/src/extra/libs/rlottie/: lv_rlottie.c
    ./littleVGL/gui/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./littleVGL/gui/src/extra/others/gridnav/: lv_gridnav.c
    ./littleVGL/gui/src/extra/others/monkey/: lv_monkey.c
    ./littleVGL/gui/src/extra/others/snapshot/: lv_snapshot.c
    ./littleVGL/gui/src/extra/themes/basic/: lv_theme_basic.c
    ./littleVGL/gui/src/extra/themes/default/: lv_theme_default.c
    ./littleVGL/gui/src/extra/themes/mono/: lv_theme_mono.c
    ./littleVGL/gui/src/extra/widgets/animimg/: lv_animimg.c
    ./littleVGL/gui/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./littleVGL/gui/src/extra/widgets/chart/: lv_chart.c
    ./littleVGL/gui/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./littleVGL/gui/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./littleVGL/gui/src/extra/widgets/keyboard/: lv_keyboard.c
    ./littleVGL/gui/src/extra/widgets/led/: lv_led.c
    ./littleVGL/gui/src/extra/widgets/list/: lv_list.c
    ./littleVGL/gui/src/extra/widgets/menu/: lv_menu.c
    ./littleVGL/gui/src/extra/widgets/meter/: lv_meter.c
    ./littleVGL/gui/src/extra/widgets/msgbox/: lv_msgbox.c
    ./littleVGL/gui/src/extra/widgets/span/: lv_span.c
    ./littleVGL/gui/src/extra/widgets/spinbox/: lv_spinbox.c
    ./littleVGL/gui/src/extra/widgets/spinner/: lv_spinner.c
    ./littleVGL/gui/src/extra/widgets/tabview/: lv_tabview.c
    ./littleVGL/gui/src/extra/widgets/tileview/: lv_tileview.c
    ./littleVGL/gui/src/extra/widgets/win/: lv_win.c
    ./littleVGL/gui/src/extra/: lv_extra.c
    ./littleVGL/gui/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./littleVGL/gui/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./littleVGL/gui/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./littleVGL/gui/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group gui_port
    ./littleVGL/gui/examples/porting/: lv_port_disp.c
  group lcd
    ./src/lcd/: lcd_drv.c
  group spi
    ./src/spi/: spi.c
  group gui_examples
    ./littleVGL/gui/examples/widgets/calendar/: lv_example_calendar_1.c
    ./littleVGL/gui/examples/widgets/chart/: lv_example_chart_2.c
