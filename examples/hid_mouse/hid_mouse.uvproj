# Keil uVision project hid_mouse.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: hid_mouse +hex
  AfterMake: fromelf.exe --bin -o hid_mouse.bin ./output/hid_mouse.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,VALUE_PRESSED=0,SIMULATION
  c misc: --gnu
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33763328 size 315392
  memory RVCT9: RAM 536892760 size 10920
  group APP
    ./src/: main.c profile.c
    ../peripheral_console/src/: key_detector.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/exp/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c peripheral_pinctrl.c peripheral_pwm.c peripheral_qdec.c
  group Tools
    ../../src/Tools/: att_db_util.c trace.c blink.c
