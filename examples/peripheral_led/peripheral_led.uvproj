# Keil uVision project peripheral_led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_led +hex
  AfterMake: fromelf.exe --bin -o peripheral_led.bin ./output/peripheral_led.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_RGB_LED
  c misc: --gnu
  c include: ../../bundles/extension/inc;../../bundles/extension/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 172032 size 368640
  memory RVCT9: RAM 536900728 size 35720
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/extension/ING9188xx/: symdefs.m
  group BSP
    ../../src/BSP/: board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c peripheral_pwm.c peripheral_gpio.c
  group Tools
    ../../src/Tools/: rf_util.c
