# Keil uVision project gatt_relay.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: gatt_relay +hex
  AfterMake: fromelf.exe --bin -o gatt_relay.bin ./output/gatt_relay.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,iprintf=platform_printf,BOARD_USE_RGB_LED
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536901896 size 34552
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_pwm.c peripheral_gpio.c
  group Tools
    ../../src/Tools/: att_db_util.c trace.c gatt_client_util.c
