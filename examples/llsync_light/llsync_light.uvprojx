# Keil uVision project llsync_light.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: llsync_light +hex
  AfterMake: fromelf.exe --bin -o llsync_light.bin ./output/llsync_light.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\data_template;.\qcloud_iot_explorer_ble\inc;.\qcloud_iot_explorer_ble\src\internal_inc;./src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 122880
  memory RVCT9: RAM 536893408 size 10272
  group APP
    ./src/: main.c profile.c hal.c
    ./data_template/: ble_qiot_template.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9185xx/: symdefs.m
  group BSP
    ../../src/BSP/: rgb_led.c eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
  group Tools
    ../../src/Tools/: trace.c att_db_util.c
  group LLSync
    ./qcloud_iot_explorer_ble/src/core/: ble_qiot_llsync_data.c ble_qiot_llsync_device.c ble_qiot_llsync_event.c ble_qiot_service.c ble_qiot_llsync_utils.c ble_qiot_llsync_ota.c
    ./qcloud_iot_explorer_ble/src/utils/: ble_qiot_utils_base64.c ble_qiot_utils_hmac.c ble_qiot_utils_log.c ble_qiot_utils_md5.c ble_qiot_utils_sha1.c
software components: CMSIS:CORE 4.3.0
