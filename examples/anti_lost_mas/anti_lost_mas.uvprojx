# Keil uVision project anti_lost_mas.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: anti_lost_mas +hex
  AfterMake: fromelf.exe --bin -o anti_lost_mas.bin ./output/anti_lost_mas.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_BUZZER
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900736 size 35712
  group APP
    ./src/: main.c profile.c
    ../anti_lost_sla/src/: dev_info.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c peripheral_pwm.c peripheral_gpio.c
  group Tools
    ../../src/Tools/: ad_parser.c blink.c
software components: CMSIS:CORE 5.5.0
