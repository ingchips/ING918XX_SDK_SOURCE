# Keil uVision project peripheral_piano.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_piano +hex
  AfterMake: fromelf.exe --bin -o peripheral_piano.bin ./output/peripheral_piano.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_BUZZER
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900728 size 35720
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c peripheral_pwm.c
software components: CMSIS:CORE 4.3.0
