# Keil uVision project eatt.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: eatt +hex
  AfterMake: fromelf.exe --bin -o eatt.bin ./output/eatt.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x30000 size 0x54000
  memory RVCT9: RAM 0x20007650 size 0x89b0
  group APP
    ./src/: main.c profile.c eatt_uart_console.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/exp/ING9188xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../src/Tools/: trace.c att_db_util.c gatt_client_util.c platform_util.c rf_util.c str_util.c btstack_mt.c btstack_sync.c
software components: CMSIS:CORE 4.3.0
