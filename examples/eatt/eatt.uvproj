# Keil uVision project eatt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: eatt +hex
  AfterMake: fromelf.exe --bin -o eatt.bin ./output/eatt.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,APP_ROLE=0, iprintf=platform_printf
  c misc: --gnu
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 196608 size 344064
  memory RVCT9: RAM 536901208 size 35240
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/exp/ING9188xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../src/Tools/: trace.c att_db_util.c btstack_sync.c gatt_client_util.c str_util.c
