# Keil uVision project peripheral_console_realtime.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: peripheral_console_realtime +hex
  AfterMake: fromelf.exe --bin -o peripheral_console_realtime.bin ./output/peripheral_console_realtime.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/noos_mini/inc;../../bundles/noos_mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536889672 size 38584
  group APP
    ./src/: main.c noos_impl.c
    ../peripheral_console/src/: profile.c service_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
