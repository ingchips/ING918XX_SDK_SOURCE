# Keil uVision project peripheral_console_realtime.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: peripheral_console_realtime +hex
  AfterMake: fromelf.exe --bin -o peripheral_console_realtime.bin ./output/peripheral_console_realtime.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,LISTEN_TO_POWER_SAVING,POWER_SAVING,OPT_RAM_CODE
  c include: ../../bundles/noos_mini/inc;../../bundles/noos_mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33710080 size 368640
  memory RVCT9: RAM 536887912 size 40344
  scatter file: .\peripheral_console_realtime.sct
  group APP
    ./src/: main.c noos_impl.c
    ../peripheral_console/src/: profile.c service_console.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_gpio.c
software components: CMSIS:CORE 4.3.0
