# Keil uVision project peripheral_console.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_console +hex
  AfterMake: fromelf.exe --bin -o peripheral_console.bin ./output/peripheral_console.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_WATCHDOG,USE_POWER_LIB
  c misc: --gnu
  c include: ../../bundles/mini/inc;../../bundles/mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536884712 size 51736
  group APP
    ./src/: main.c profile.c service_console.c key_detector.c
    ../../src/Tools/: power_ctrl.lib
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/mini/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_gpio.c peripheral_timer.c
  group Tools
    ../../src/Tools/: trace.c
