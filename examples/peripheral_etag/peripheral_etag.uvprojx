# Keil uVision project peripheral_etag.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_etag +hex
  AfterMake: fromelf.exe --bin -o peripheral_etag.bin ./output/peripheral_etag.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,OPTIONAL_RF_CLK,HEIGHT=128,PROD_VER
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900712 size 35736
  group APP
    ./src/: main.c profile.c Display_EPD_W21.c spi.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_ssp.c peripheral_pinctrl.c peripheral_gpio.c
software components: CMSIS:CORE 4.3.0
