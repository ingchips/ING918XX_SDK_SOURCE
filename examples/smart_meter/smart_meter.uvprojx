# Keil uVision project smart_meter.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: smart_meter +hex
  AfterMake: fromelf.exe --bin -o smart_meter.bin ./output/smart_meter.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900728 size 35720
  group APP
    ./src/: main.c profile.c uart_console.c thermo_service.c
  group StartUP
    ./src/: startup_ING91800.s
    ../../bundles/typical/ing9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../src/Tools/: ad_parser.c trace.c
software components: CMSIS:CORE 4.3.0
