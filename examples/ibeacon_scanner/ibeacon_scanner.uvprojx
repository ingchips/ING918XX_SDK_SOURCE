# Keil uVision project ibeacon_scanner.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: ibeacon_scanner +hex
  AfterMake: fromelf.exe --bin -o ibeacon_scanner.bin ./output/ibeacon_scanner.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../bundles/typical/inc/os/portable/GCC/ARM_CM3;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 122880
  memory RVCT9: RAM 536893400 size 10280
  group APP
    ./src/: main.c profile.c service_ibeacon.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9185xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_pwm.c peripheral_timer.c
  group Tools
    ../../src/Tools/: ad_parser.c
software components: CMSIS:CORE 4.3.0
