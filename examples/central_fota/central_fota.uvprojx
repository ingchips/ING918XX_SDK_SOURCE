# Keil uVision project central_fota.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: central_fota +hex
  AfterMake: fromelf.exe --bin -o central_fota.bin ./output/central_fota.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,TARGET_FAMILY=0
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c ing918_fota_client.o
    ../../examples-gcc/central_fota/src/: profile.c gatt_client_async_helper.c sec_fota_utils.c
    ../../src/Tools/: ing918_uecc.lib
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../src/Tools/: ad_parser.c trace.c gatt_client_util.c malloc_override.c platform_util.c
software components: CMSIS:CORE 4.3.0
