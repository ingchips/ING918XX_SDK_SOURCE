# Keil uVision project central_fota.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: central_fota +hex
  AfterMake: fromelf.exe --bin -o central_fota.bin ./output/central_fota.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,TARGET_FAMILY=0
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900728 size 35720
  group APP
    ./src/: main.c fota_client.o
    ../../examples-gcc/central_fota/src/: gatt_client_async_helper.c profile.c sec_fota_utils.c
    ../../src/Tools/: ing918_uecc.lib
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../src/Tools/: ad_parser.c trace.c gatt_client_util.c platform_util.c
