# Keil uVision project peripheral_all_in_one.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_all_in_one +hex
  AfterMake: fromelf.exe --bin -o peripheral_all_in_one.bin ./output/peripheral_all_in_one.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,OPTIONAL_RF_CLK,HEIGHT=128
  c misc: --gnu
  c include: ..\peripheral_etag\src;..\peripheral_pedometer\src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536910768 size 25680
  group APP
    ./src/: main.c profile.c
    ../peripheral_etag/src/: Display_EPD_W21.c spi.c
    ../peripheral_pedometer/src/: bma2x2_support.c step_calc.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/: symdefs.m
  group BSP
    ../../src/BSP/: bma2x2.c bme280.c iic.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_ssp.c peripheral_pinctrl.c peripheral_pwm.c peripheral_i2c.c peripheral_adc.c peripheral_timer.c peripheral_gpio.c
software components: CMSIS:CORE 4.3.0
