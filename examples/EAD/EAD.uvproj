# Keil uVision project EAD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: EAD +hex
  AfterMake: fromelf.exe --bin -o EAD.bin ./output/EAD.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/exp/inc;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/exp/inc/os;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/StartUP/ing918;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools;../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src
  library: MicroLIB
  memory RVCT4: ROM 196608 size 344064
  memory RVCT9: RAM 536901192 size 35256
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/bundles/exp/ING9188xx/: symdefs.m
  group BSP
    ../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/BSP/: eflash.c
  group FWlib
    ../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c
  group Tools
    ../../../../../Users/yuxiz/AppData/Roaming/Local/Program/ING_SDK/sdk/src/Tools/: trace.c
