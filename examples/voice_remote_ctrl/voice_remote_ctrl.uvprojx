# Keil uVision project voice_remote_ctrl.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: voice_remote_ctrl +hex
  AfterMake: fromelf.exe --bin -o voice_remote_ctrl.bin ./output/voice_remote_ctrl.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEV_BOARD
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20009b90 size 0x6470
  group APP
    ./src/: main.c profile.c audio_service.c kb_scan.c kb_service.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_adc.c peripheral_pinctrl.c peripheral_gpio.c peripheral_pwm.c
  group Tools
    ../../src/Tools/: audio.c att_db_util.c blink.c
software components: CMSIS:CORE 4.3.0
