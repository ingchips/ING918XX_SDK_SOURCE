# Keil uVision project voice_remote_ctrl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: voice_remote_ctrl +hex
  AfterMake: fromelf.exe --bin -o voice_remote_ctrl.bin ./output/voice_remote_ctrl.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEV_BOARD
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536910768 size 25680
  group APP
    ./src/: main.c profile.c audio_service.c kb_scan.c kb_service.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_adc.c peripheral_pinctrl.c peripheral_gpio.c peripheral_pwm.c
  group Tools
    ../../src/Tools/: audio.c att_db_util.c blink.c
