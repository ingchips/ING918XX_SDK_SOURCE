# Keil uVision project io_over_ble_sla.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: io_over_ble_sla +hex
  AfterMake: fromelf.exe --bin -o io_over_ble_sla.bin ./output/io_over_ble_sla.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,IO_TYPE=IO_TYPE_UART
  c misc: --gnu
  c include: ../io_over_ble_mas\src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20009b90 size 0x6470
  group APP
    ./src/: main.c profile.c
    ../io_over_ble_mas/src/: io_interf.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_pwm.c peripheral_gpio.c peripheral_ssp.c
  group Tools
    ../../src/Tools/: blink.c
software components: CMSIS:CORE 4.3.0
