# Keil uVision project io_over_ble_sla.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: io_over_ble_sla +hex
  AfterMake: fromelf.exe --bin -o io_over_ble_sla.bin ./output/io_over_ble_sla.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../io_over_ble_mas\src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536900720 size 35728
  group APP
    ./src/: main.c profile.c
    ../io_over_ble_mas/src/: io_interf.c uart_driver.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c peripheral_pwm.c peripheral_gpio.c peripheral_ssp.c
  group Tools
    ../../src/Tools/: blink.c rf_util.c ring_buf.c
