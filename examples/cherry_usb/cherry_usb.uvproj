# Keil uVision project cherry_usb.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: cherryusb_os_mini +hex
  AfterMake: fromelf.exe --bin -o cherryusb_os_mini.bin ./output/cherry_usb.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/mini/inc;../../bundles/mini/inc/os;../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/noos_mini/inc;../../bundles/noos_mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536889672 size 38584
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/mini/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../src/Tools/: trace.c
