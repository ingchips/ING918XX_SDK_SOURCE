# Keil uVision project CherryUsbNoos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91600 INGCHIPS
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x2200000) IRAM(0x20000000-0x20008000)
  output: CherryUsbNoos +hex
  AfterMake: fromelf.exe --bin -o CherryUsbNoos.bin ./output/CherryUsbNoos.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/noos_mini/inc;../../bundles/noos_mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src;.\FreeRTOS\include;.\FreeRTOS;.\CherryUSB\class\hid;.\CherryUSB\class\cdc;.\CherryUSB\class\msc;.\CherryUSB\port\dwc2;.\CherryUSB;.\CherryUSB\common;.\CherryUSB\class\hub
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20004748 size 0x98b8
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../src/Tools/: trace.c
  group FreeRTOS
    ./FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group CherryUSB
    ./CherryUSB/: usb_config.h
    ./CherryUSB/core/: usbh_core.c usbd_core.c
    ./CherryUSB/osal/: usb_osal_freertos.c
    ./CherryUSB/port/dwc2/: usb_hc_dwc2.c usb_glue_ingchips.c usb_dc_dwc2.c
    ./CherryUSB/class/msc/: usbh_msc.c
    ./CherryUSB/class/hub/: usbh_hub.c
    ./CherryUSB/class/hid/: usbd_hid.c
    ./CherryUSB/demo/: hid_mouse_template.c usb_host.c
