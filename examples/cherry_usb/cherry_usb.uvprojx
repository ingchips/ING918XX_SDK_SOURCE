# Keil uVision project cherry_usb.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: cherry_usb +hex
  AfterMake: fromelf.exe --bin -o cherry_usb.bin ./output/cherry_usb.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\CherryUSB\class\hid;.\CherryUSB\class\cdc;.\CherryUSB\class\msc;.\CherryUSB\port\dwc2;.\CherryUSB\core;.\CherryUSB;.\CherryUSB\common;.\CherryUSB\class\hub;..\peripheral_console_freertos\FreeRTOS\include;..\peripheral_console_freertos\FreeRTOS\portable\GCC\ARM_CM4F;.\src;../../bundles/noos_mini/inc;../../bundles/noos_mini/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 33718272 size 360448
  memory RVCT9: RAM 536889672 size 38584
  link misc: --legacyalign
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/noos_mini/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    ../../src/Tools/: trace.c
  group CherryUSB
    ./CherryUSB/: usb_config.h
    ./CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_ingchips.c usb_hc_dwc2.c
    ./CherryUSB/core/: usbd_core.c usbh_core.c
    ./CherryUSB/osal/: usb_osal_freertos.c
    ./CherryUSB/class/msc/: usbh_msc.c
    ./CherryUSB/class/hub/: usbh_hub.c
    ./CherryUSB/class/hid/: usbd_hid.c
    ./CherryUSB/demo/: hid_mouse_template.c
  group FreeRTOS
    ../peripheral_console_freertos/FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../peripheral_console_freertos/FreeRTOS/portable/MemMang/: heap_4.c
    ../peripheral_console_freertos/src/: port.c
software components: CMSIS:CORE 4.3.0
