# Keil uVision project peripheral_console_rt-thread.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_console_rt-thread +hex
  AfterMake: fromelf.exe --bin -o peripheral_console_rt-thread.bin ./output/peripheral_console_rt-thread.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,LISTEN_TO_POWER_SAVING,POWER_SAVING
  c include: ./rt-thread/include;./src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c
    ../peripheral_console/src/: profile.c service_console.c
  group StartUP
    ../../bundles/typical/ING9187xx/: symdefs.m
    ./src/: startup_ing91800.s
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
  group rt-thread
    ./rt-thread/src/: clock.c cpu.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c gen_os_impl.c
    ./rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
software components: CMSIS:CORE 4.3.0
