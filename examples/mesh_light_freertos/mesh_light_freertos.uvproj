# Keil uVision project mesh_light_freertos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: mesh_light_freertos +hex
  AfterMake: fromelf.exe --bin -o mesh_light_freertos.bin ./output/mesh_light_freertos.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ./FreeRTOS/include;./src;../../bundles/noos_typical/inc;../../bundles/noos_typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  group APP
    ./src/: main.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/noos_typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../src/Tools/: trace.c
  group RTOS
    ./FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
