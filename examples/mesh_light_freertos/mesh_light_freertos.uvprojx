# Keil uVision project mesh_light_freertos.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: mesh_light_freertos +hex
  AfterMake: fromelf.exe --bin -o mesh_light_freertos.bin ./output/mesh_light_freertos.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_RGB_LED
  c include: ./FreeRTOS/include;./src;..\..\src\SigMesh\inc;..\..\src\SigMesh\inc\mesh;..\..\src\SigMesh\inc\mesh_host;../../bundles/noos_typical/inc;../../bundles/noos_typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x24000 size 0x60000
  memory RVCT9: RAM 0x20001588 size 0xea78
  group APP
    ./src/: main.c profile.c mesh_profile.c mesh_port_stack.c mesh_storage_app.c mesh_storage_low_level.c mesh_manage_conn_and_scan.c app_config.h app_debug.h
  group TEST_CODE
    ./src/: BUTTON_TEST.c RF_TEST.C
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/noos_typical/ING9188xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_pinctrl.c peripheral_sysctrl.c peripheral_uart.c peripheral_rtc.c peripheral_gpio.c
  group Tools
    ../../src/Tools/: trace.c
  group RTOS
    ./FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group SigMesh
    ../../src/SigMesh/: SigMesh.lib
    ../../src/SigMesh/src/: hal_flash_bank_eflash.c
    ./src/: mesh_port_low_level_init.c
software components: CMSIS:CORE 4.3.0
