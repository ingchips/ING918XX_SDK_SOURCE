# Keil uVision project peripheral_console_freertos.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: peripheral_console_freertos +hex
  AfterMake: fromelf.exe --bin -o peripheral_console_freertos.bin ./output/peripheral_console_freertos.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,LISTEN_TO_POWER_SAVING,POWER_SAVING
  c misc: --gnu
  c include: ./FreeRTOS/include;./src;../../bundles/noos_typical/inc;../../bundles/noos_typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 147456 size 393216
  memory RVCT9: RAM 536874392 size 62056
  group APP
    ./src/: main.c port.c
    ../peripheral_console/src/: key_detector.c profile.c service_console.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/noos_typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
  group RTOS
    ./FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
