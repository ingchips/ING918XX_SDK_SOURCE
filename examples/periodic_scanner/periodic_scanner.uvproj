# Keil uVision project periodic_scanner.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: periodic_scanner +hex
  AfterMake: fromelf.exe --bin -o periodic_scanner.bin ./output/periodic_scanner.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,CTE
  c misc: --gnu
  c include: ..\ibeacon_scanner\src;../../bundles/typical/inc;../../bundles/typical/inc/os;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536902236 size 34212
  group APP
    ./src/: main.c profile.c str_utils.c
    ../smart_meter/src/: thermo_service.c
    ../ibeacon_scanner/src/: service_ibeacon.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: ad_parser.c
