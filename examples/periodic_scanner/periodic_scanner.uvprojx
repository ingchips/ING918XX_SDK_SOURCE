# Keil uVision project periodic_scanner.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: periodic_scanner +hex
  AfterMake: fromelf.exe --bin -o periodic_scanner.bin ./output/periodic_scanner.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\ibeacon_scanner\src;../../bundles/typical/inc/os/portable/GCC/ARM_CM3;../../bundles/typical/inc/os/portable/RVDS/ARM_CM3;../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536901904 size 34544
  group APP
    ./src/: main.c profile.c
    ../smart_meter/src/: thermo_service.c
    ../ibeacon_scanner/src/: service_ibeacon.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/typical/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: ad_parser.c str_util.c
software components: CMSIS:CORE 4.3.0
