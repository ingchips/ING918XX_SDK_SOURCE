# Keil uVision project uart_console.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: uart_console +hex
  AfterMake: fromelf.exe --bin -o uart_console.bin ./output/uart_console.axf
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,iprintf=platform_printf,TRACE_BUFF_SIZE=1024
  c include: ../../bundles/exp/inc;../../bundles/exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 196608 size 344064
  memory RVCT9: RAM 536901208 size 35240
  group APP
    ./src/: main.c profile.c uart_console.c
  group StartUP
    ./src/: startup_ING91800.s
    ../../bundles/exp/ing9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: trace.c str_util.c gatt_client_util.c btstack_mt.c btstack_sync.c
software components: CMSIS:CORE 5.5.0
