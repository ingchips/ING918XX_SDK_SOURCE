# Keil uVision project ext_raw_packet.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: ext_raw_packet +hex
  AfterMake: fromelf.exe --bin -o ext_raw_packet.bin ./output/ext_raw_packet.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,CTE_ON,FOR_TX=1
  c include: ../../bundles/extension/inc;../../bundles/extension/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 172032 size 368640
  memory RVCT9: RAM 536900720 size 35728
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/extension/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c
  group Tools
    ../../src/Tools/: rf_util.c str_util.c
software components: CMSIS:CORE 4.3.0
