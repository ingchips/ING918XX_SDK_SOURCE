# Keil uVision project ext_raw_packet.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: ext_raw_packet +hex
  AfterMake: fromelf.exe --bin -o ext_raw_packet.bin ./output/ext_raw_packet.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,FOR_TX=0
  c misc: --gnu
  c include: ../../bundles/extension/inc;../../bundles/extension/inc/os;../../bundles/extension/inc/os/portable/RVDS/ARM_CM3;../../src/BSP;../../src/FWlib;../../src/StartUP;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536902240 size 34208
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/extension/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
