# Keil uVision project thermo_ota.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ing91800 INGCHIPS
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: thermo_ota +hex
  AfterMake: fromelf.exe --bin -o thermo_ota.bin ./output/thermo_ota.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 163840 size 376832
  memory RVCT9: RAM 536900896 size 35552
  group APP
    ./src/: main.c profilestask.c fota.c
    ../../src/Tools/: ing918_uecc.lib
  group StartUP
    ../../src/StartUP/: startup_cm32gpm3.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: iic.c eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_i2c.c peripheral_uart.c peripheral_sysctrl.c peripheral_timer.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: att_db_util.c
