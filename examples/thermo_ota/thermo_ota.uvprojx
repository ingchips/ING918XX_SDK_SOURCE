# Keil uVision project thermo_ota.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00004000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thermo_ota +hex
  AfterMake: fromelf.exe --bin -o thermo_ota.bin ./output/thermo_ota.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BME280_32BIT_ENABLE,PRINT_ALL,V1,BOARD_USE_THERMO
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 155648 size 385024
  memory RVCT9: RAM 536901904 size 34544
  group APP
    ./src/: main.c profilestask.c fota.c
    ../../src/Tools/: ing918_uecc.lib
  group StartUP
    ../../src/StartUP/: startup_cm32gpm3.s
    ../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: iic.c eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_i2c.c peripheral_uart.c peripheral_sysctrl.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: att_db_util.c
software components: CMSIS:CORE 4.3.0
