# Keil uVision project ext_ackable_packet.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ING91800 INGCHIPS
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: ext_ackable_packet +hex
  AfterMake: fromelf.exe --bin -o ext_ackable_packet.bin ./output/ext_ackable_packet.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,FOR_INITIATOR=1
  c misc: --gnu
  c include: ../../bundles/extension/inc;../../bundles/extension/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 172032 size 368640
  memory RVCT9: RAM 536900888 size 35560
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/extension/ING9188xx/: symdefs.m
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c
  group Tools
    ../../src/Tools/: trace.c
